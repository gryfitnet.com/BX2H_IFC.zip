Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-06-07T15:00:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 07 15:00:25 2019 * Host: DESKTOP-088PFGA * Database: C:\Users\KOMORO~1\AppData\Local\Temp\{67B12EE1-6758-4B27-BF88-76D52DF828C3}\ifc * Database version: 5507 * Database creation date: Fri Jun 07 15:00:24 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 07 15:00:24 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 07 15:00:24 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: GRYFIT BX-2H, D=100 + KM, KM=150 + WT72C + EI230V, D=100. DK=140. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=100 + KM, KM=150 + WT72C + EI230V, D=100. DK=140. S=6. P=190:922037
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=100 + KM, KM=150 + WT72C + EI230V, D=100. DK=140. S=6. P=190

# IfcFlowTerminal: GRYFIT BX-2H, D=100 + KM, KM=150 + WT72C, D=100. DK=140. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=100 + KM, KM=150 + WT72C, D=100. DK=140. S=6. P=190:922033
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=100 + KM, KM=150 + WT72C, D=100. DK=140. S=6. P=190

# IfcFlowTerminal: GRYFIT BX-2H, D=125 + KM, KM=150 + WT72C + EI230V, D=125. DK=162. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=125 + KM, KM=150 + WT72C + EI230V, D=125. DK=162. S=6. P=190:922038
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=125 + KM, KM=150 + WT72C + EI230V, D=125. DK=162. S=6. P=190

# IfcFlowTerminal: GRYFIT BX-2H, D=125 + KM, KM=150 + WT72C, D=125. DK=162. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=125 + KM, KM=150 + WT72C, D=125. DK=162. S=6. P=190:922034
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=125 + KM, KM=150 + WT72C, D=125. DK=162. S=6. P=190

# IfcFlowTerminal: GRYFIT BX-2H, D=160 + KM, KM=150 + WT72C + EI230V, D=160. DK=212. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=160 + KM, KM=150 + WT72C + EI230V, D=160. DK=212. S=6. P=190:922039
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=160 + KM, KM=150 + WT72C + EI230V, D=160. DK=212. S=6. P=190

# IfcFlowTerminal: GRYFIT BX-2H, D=160 + KM, KM=150 + WT72C, D=160. DK=212. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=160 + KM, KM=150 + WT72C, D=160. DK=212. S=6. P=190:922035
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=160 + KM, KM=150 + WT72C, D=160. DK=212. S=6. P=190

# IfcFlowTerminal: GRYFIT BX-2H, D=200 + KM, KM=150 + WT72C + EI230V, D=200. DK=252. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=200 + KM, KM=150 + WT72C + EI230V, D=200. DK=252. S=6. P=190:922040
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=200 + KM, KM=150 + WT72C + EI230V, D=200. DK=252. S=6. P=190

# IfcFlowTerminal: GRYFIT BX-2H, D=200 + KM, KM=150 + WT72C, D=200. DK=252. S=6. P=190, GRYFIT BX-2H, Przeciwpożarowy zawór odcinający:GRYFIT BX-2H, D=200 + KM, KM=150 + WT72C, D=200. DK=252. S=6. P=190:922036
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-2H, D=200 + KM, KM=150 + WT72C, D=200. DK=252. S=6. P=190
